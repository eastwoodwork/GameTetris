# Keil uVision project myTetris.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: nano8x8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CalculateCPS.c Can.c KeyDecode.c Main.c Move.c server.c BattleOver.c updateLightLayer.c Interrupt.c
